# Keil uVision project EEPROM.uvproj, settings and files
target rhydoLABZ LPC2148 Board (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: EEPROM +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Files
    ./: Startup.s Delays.c LCD.c main.c UART.c I2C.c
